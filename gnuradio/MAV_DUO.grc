options:
  parameters:
    author: Irfan Annuar - USC ISI SERC
    copyright: USC ISI SERC
    description: MAVERIC CubeSat ASM+Golay Uplink (AX100 Mode 5) + RF B RX / RF A TX
    generate_options: qt_gui
    id: MAV_DUO
    output_language: python
    title: MAVERIC DUAL FRAME
  states: {}

blocks:
- name: decoder_options
  id: variable
  parameters:
    comment: |-
      gr-satellites options matched to the database: --syncword_threshold
      only parses when an AX100/FX.25 deframer is in the file (a pure AX.25
      database would abort argparse). Mirrors _decoder_options() in MAV_DUO.py.
    value: ('--syncword_threshold 6' * any(l.split('#')[0].strip().startswith('framing:') and ('AX100' in l.split('#')[0] or 'FX.25' in l.split('#')[0]) for l in (open(decoder_yml).read() if __import__('os').path.isfile(decoder_yml) else '').splitlines()))
  states: {}
- name: decoder_yml
  id: variable
  parameters:
    comment: |-
      Per-mission decoder database: GSS_DECODER_YML override, otherwise
      the exact decoders/<MISSION>_DECODER.yml beside this flowgraph. Missing profiles
      fail closed; there is no cross-mission MAVERIC fallback. Mirrors _decoder_yml().
    value: ((__import__('os').environ.get('GSS_DECODER_YML') or '').strip() or __import__('os').path.join(__import__('os').path.dirname(__import__('os').path.abspath(__import__('sys').argv[0])), 'decoders', ((__import__('os').environ.get('GSS_MISSION') or 'maveric').strip().upper() + '_DECODER.yml')))
  states: {}
- name: rx_decim
  id: variable
  parameters:
    comment: RX decimation 1Msps -> 200ksps for satellite_decoder + displays
    value: '5'
  states: {}
- name: rx_lo_offset
  id: variable
  parameters:
    comment: |-
      RX LO parks this far above rx_freq; doppler rides the DSP NCO.
      Single-sourced from tracking.control.rx_lo_offset_hz via the GSS_RX_LO_OFFSET_HZ
      env var RadioService injects; the literal is the standalone-launch fallback.
    value: float(__import__('os').environ.get('GSS_RX_LO_OFFSET_HZ', 250e3))
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      TX LO parks this far below tx_freq; keeps TX LO leak + LO-vs-LO
      beat products out of the RX passband. Single-sourced from tracking.control.tx_lo_offset_hz
      via GSS_TX_LO_OFFSET_HZ; the literal is the standalone-launch fallback.
    value: float(__import__('os').environ.get('GSS_TX_LO_OFFSET_HZ', -400e3))
  states: {}
- name: baud
  id: variable
  parameters:
    comment: |-
      Uplink baud from the mission decoder database: its first AX100
      ASM+Golay transmitter (9600 MAVERIC, 4800 SUCHAI-4), else 9600.
      Mirrors tx_baudrate() in decoder_profiles.py.
    value: next((int(t['baudrate']) for t in ((__import__('yaml').safe_load(open(decoder_yml).read()) or {}).get('transmitters') or {}).values() if isinstance(t, dict) and t.get('framing') == 'AX100 ASM+Golay'), 9600) if __import__('os').path.isfile(decoder_yml) else 9600
  states: {}
- name: rx_freq
  id: variable
  parameters:
    comment: |-
      RX center frequency. Seeded from the GSS_RX_FREQ_HZ env var RadioService
      injects (config rx.frequency / tracking.frequencies.rx_hz); the literal is the
      standalone-launch fallback. Doppler retunes live via 52003.
    value: float(__import__('os').environ.get('GSS_RX_FREQ_HZ', 437.575e6))
  states: {}
- name: tx_freq
  id: variable
  parameters:
    comment: |-
      TX center frequency. Seeded from the GSS_TX_FREQ_HZ env var RadioService
      injects (config tx.frequency / tracking.frequencies.tx_hz); the literal is the
      standalone-launch fallback. Doppler retunes live via 52004.
    value: float(__import__('os').environ.get('GSS_TX_FREQ_HZ', 437.575e6))
  states: {}
- name: modindex
  id: variable
  parameters:
    comment: |-
      AX100 auto default: the flight param list shows modindex 0.0 =
      AUTOMATIC, and the manual's auto table picks h = 1/1.5 for 1300-60000
      baud. This exact value was hardware-verified against the flight unit
      in the Mode 5 uplink bench tests. ROADS 2's measured h=0.5 is that
      bird's own config, not the AX100 default.
    value: 1/1.5
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: SDR RF TX burst gain (applied by the PTT gate during TX; hardware idles at 0 dB)
    gui_hint: 0,1,1,1
    label: TX Gain (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      SDR RF RX gain (B210 max 76 dB). Boot value from GSS_RX_GAIN
      (platform.radio.rx_gain, injected by RadioService); the slider
      still overrides live.
    gui_hint: 4,0,1,2
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: float(__import__('os').environ.get('GSS_RX_GAIN', 40))
  states: {}
- name: rx_bw
  id: variable
  parameters:
    comment: |-
      RX channel filter cutoff, one-sided (50e3 = +/-50 kHz = 100 kHz
      channel). Boot value from GSS_RX_BW_HZ (platform.radio.rx_bw, injected
      by RadioService); applies on radio start. disp_decim rebuilds the
      GUI display span to match.
    value: float(__import__('os').environ.get('GSS_RX_BW_HZ', 50e3))
  states: {}
- name: disp_decim
  id: variable
  parameters:
    comment: |-
      Display-only zoom: GUI freq/waterfall span (view Nyquist =
      100k/disp_decim) tracks rx_bw. Decoder, recorders, and the
      waterfall logger stay on the full 200 ksps tap.
    value: max(1, min(20, int((samp_rate / (2 * rx_decim)) // rx_bw)))
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      Display zoom tap: plain sample dropping is safe (channel FIR
      is >=59 dB down past rx_bw+15k)
    n: disp_decim
    type: complex
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RX sample rate (independent of TX)
    value: '1000000'
  states: {}
- name: samp_ratetx
  id: variable
  parameters:
    comment: Fixed 2.4 Msps = 48MHz/20 with RX at 1Msps (clean B210 divisor at both baud rates)
    value: '2400000'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    comment: Baseband TX amplitude
    gui_hint: 0,0,1,1
    label: TX Amplitude
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.7'
  states: {}
- name: zmq_port_rx
  id: variable
  parameters:
    comment: |-
      ZMQ Port 
      PDU Output
    value: '"52001"'
  states: {}
- name: zmq_port_tx
  id: variable
  parameters:
    comment: |-
      ZMQ Port
      PDU Input
    value: '"52002"'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: TX amplitude control
    const: tx_amp
    type: complex
  states: {}
- name: blocks_var_to_msg_rx_gain
  id: blocks_var_to_msg
  parameters:
    comment: Sample-index live RX gain changes in both SigMF recorders
    msgname: rx_gain
    target: rx_gain
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: maveric_recordingax25u8.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    comment: 'AX100: GFSK BT=0.5, m=auto, NRZ MSB-first'
    samples_per_symbol: int(samp_ratetx/baud)
    sensitivity: (pi*modindex) / int(samp_ratetx/baud)
  states: {}
- name: epy_block_iq
  id: epy_block
  parameters:
    _source_code: |
      import json
      import os
      import threading
      import time
      import traceback
      from datetime import datetime, timezone

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Env-gated raw IQ recorder for an RX stream tap.

          Two instances run in this flowgraph: the pass recorder on the decimated
          200 ksps stream (GSS_IQ_RECORD, `platform.radio.iq_record`, 8 GB cap)
          and the diagnostic raw recorder on the pre-decimation 1 Msps stream
          (GSS_IQ_RAW_RECORD, `platform.radio.iq_raw_record`, nominally 50 GB).
          Files are created exclusively, never appended, so a same-second restart
          cannot join two runs. The first UHD ``rx_time`` tag (the B210 clock is
          synchronized to host UTC before streaming) stamps sample zero with its
          fractional seconds; later tags preserve discontinuity boundaries.
          Doppler commands and live gain changes are written immediately as
          sample-indexed SigMF capture/annotation entries. Every failure path
          prints and disables the block — capture must never take down the radio.

          Offline replay: gr_satellites <MISSION>_DECODER.yml --iq --samp_rate 200e3
          --rawfile <capture>.sigmf-data
          """

          MAX_BYTES = 8_000_000_000  # ~83 min of 200 ksps complex64

          def __init__(self):
              samp_rate = 200_000.0
              prefix = "iq"
              gate_env = "GSS_IQ_RECORD"
              max_bytes = self.MAX_BYTES
              extra_meta = {
                  "maveric:decoder_yml": os.path.basename(
                      os.environ.get("GSS_DECODER_YML", "")),
                  "maveric:radio_script": "MAV_DUO",
                  "maveric:tap": "post_fir_200k",
              }
              cap_env = "GSS_IQ_MAX_BYTES"
              gr.sync_block.__init__(self, name="iq_recorder",
                                     in_sig=[np.complex64], out_sig=None)
              self.message_port_register_in(pmt.intern("command"))
              self.set_msg_handler(pmt.intern("command"), self._handle_tune_command)
              self._file = None
              self._data_path = ""
              self._meta_path = ""
              self._written = 0
              self._samp_rate = float(samp_rate)
              self._lock = threading.RLock()
              self._rx_time_key = pmt.intern("rx_time")
              self._rx_time_seen = False
              self._time_anchor_sample = None
              self._time_anchor_seconds = None
              self._last_frequency = None
              self._stop_reported = False
              if cap_env is None:
                  cap_env = ("GSS_IQ_RAW_MAX_BYTES" if gate_env == "GSS_IQ_RAW_RECORD"
                             else "GSS_IQ_MAX_BYTES")
              env_cap = os.environ.get(cap_env, "").strip()
              self._max_bytes = int(env_cap) if env_cap else int(
                  self.MAX_BYTES if max_bytes is None else max_bytes)
              self._meta = None
              gate = os.environ.get(gate_env, "").strip().lower()
              if gate in ("", "0", "false", "no", "off") or self._max_bytes < 8:
                  return
              try:
                  script_dir = os.path.dirname(os.path.abspath(__file__))
                  out_dir = os.environ.get("GSS_IQ_DIR") or os.path.join(script_dir, "iq")
                  os.makedirs(out_dir, exist_ok=True)
                  mission = os.environ.get("GSS_MISSION") or "maveric"
                  constructed = time.time()
                  stem = "%s_%s_%s" % (
                      prefix, mission,
                      time.strftime("%Y%m%dT%H%M%SZ", time.gmtime(constructed)))
                  self._reserve_unique_pair(out_dir, stem)
                  raw_center = os.environ.get("GSS_RX_FREQ_HZ", "")
                  capture = {"core:sample_start": 0,
                             "core:datetime": self._utc_iso(constructed),
                             "maveric:datetime_source": "construction_fallback"}
                  if raw_center:
                      self._last_frequency = float(raw_center)
                      capture["core:frequency"] = self._last_frequency
                  meta = {
                      "global": {
                          "core:datatype": "cf32_le",
                          "core:sample_rate": self._samp_rate,
                          "core:version": "1.0.0",
                          "core:recorder": "MAVERIC GSS",
                          "maveric:constructed_utc": self._utc_iso(constructed),
                      },
                      "captures": [capture],
                      "annotations": [],
                  }
                  provenance = {
                      "maveric:mission": mission,
                      "maveric:rx_gain_db": os.environ.get("GSS_RX_GAIN", ""),
                      "maveric:rx_bw_hz": os.environ.get("GSS_RX_BW_HZ", ""),
                      "maveric:rx_lo_offset_hz": os.environ.get("GSS_RX_LO_OFFSET_HZ", ""),
                      "maveric:build_sha": os.environ.get("GSS_BUILD_SHA", ""),
                  }
                  provenance.update(extra_meta or {})
                  for key, value in provenance.items():
                      if value not in ("", None):
                          meta["global"][key] = value
                  self._meta = meta
                  self._write_meta_locked()
                  print(f"iq_recorder: recording {self._data_path} "
                        f"(cap {self._max_bytes / 1e9:.1f} GB)", flush=True)
              except Exception:
                  traceback.print_exc()
                  print("iq_recorder: init failed; IQ capture disabled", flush=True)
                  self._close_quietly()

          @staticmethod
          def _utc_iso(epoch_seconds):
              return (datetime.fromtimestamp(float(epoch_seconds), timezone.utc)
                      .isoformat(timespec="microseconds").replace("+00:00", "Z"))

          def _reserve_unique_pair(self, out_dir, stem):
              for suffix in range(10_000):
                  candidate = stem if suffix == 0 else f"{stem}_{suffix:03d}"
                  data_path = os.path.join(out_dir, candidate + ".sigmf-data")
                  meta_path = os.path.join(out_dir, candidate + ".sigmf-meta")
                  try:
                      data_file = open(data_path, "xb")
                  except FileExistsError:
                      continue
                  if os.path.exists(meta_path):
                      data_file.close()
                      os.remove(data_path)
                      continue
                  self._data_path = data_path
                  self._meta_path = meta_path
                  self._file = data_file
                  return
              raise RuntimeError(f"could not allocate unique SigMF name for {stem}")

          def _write_meta_locked(self):
              if self._meta is None or not self._meta_path:
                  return
              tmp = f"{self._meta_path}.{os.getpid()}.{threading.get_ident()}.tmp"
              with open(tmp, "w") as meta_file:
                  json.dump(self._meta, meta_file, indent=2)
              os.replace(tmp, self._meta_path)

          @staticmethod
          def _pmt_number(message, key):
              if not pmt.is_dict(message):
                  return None
              value = pmt.dict_ref(message, pmt.intern(key), pmt.PMT_NIL)
              if pmt.eq(value, pmt.PMT_NIL):
                  return None
              try:
                  return float(pmt.to_python(value))
              except Exception:
                  return None

          def _event_datetime_locked(self, sample_start):
              if self._time_anchor_sample is not None:
                  elapsed = ((sample_start - self._time_anchor_sample)
                             / self._samp_rate)
                  return self._utc_iso(self._time_anchor_seconds + elapsed), "usrp_rx_time"
              return self._utc_iso(time.time()), "host_wall_clock"

          def _handle_tune_command(self, message):
              if (pmt.is_pair(message) and pmt.is_symbol(pmt.car(message))
                      and pmt.symbol_to_string(pmt.car(message)) == "rx_gain"):
                  try:
                      self.note_gain(float(pmt.to_python(pmt.cdr(message))))
                  except Exception:
                      pass
                  return
              lo_hz = self._pmt_number(message, "lo_freq")
              dsp_hz = self._pmt_number(message, "dsp_freq")
              frequency_hz = self._pmt_number(message, "freq")
              if lo_hz is not None and dsp_hz is not None:
                  frequency_hz = lo_hz - dsp_hz  # UHD RX tuning convention
              if frequency_hz is not None:
                  self.note_tune(frequency_hz, lo_hz=lo_hz, dsp_hz=dsp_hz,
                                 source="doppler_command")

          def note_tune(self, frequency_hz, *, lo_hz=None, dsp_hz=None,
                        source="live_tune"):
              with self._lock:
                  if self._file is None or self._meta is None:
                      return
                  sample_start = self._written // 8
                  stamp, stamp_source = self._event_datetime_locked(sample_start)
                  capture = {
                      "core:sample_start": sample_start,
                      "core:frequency": float(frequency_hz),
                      "core:datetime": stamp,
                      "maveric:event": source,
                      "maveric:datetime_source": stamp_source,
                  }
                  if lo_hz is not None:
                      capture["maveric:lo_freq_hz"] = float(lo_hz)
                  if dsp_hz is not None:
                      capture["maveric:dsp_freq_hz"] = float(dsp_hz)
                  if sample_start == 0:
                      self._meta["captures"][0].update(capture)
                  else:
                      self._meta["captures"].append(capture)
                  self._last_frequency = float(frequency_hz)
                  self._write_meta_locked()

          def note_gain(self, gain_db):
              with self._lock:
                  if self._file is None or self._meta is None:
                      return
                  sample_start = self._written // 8
                  stamp, stamp_source = self._event_datetime_locked(sample_start)
                  self._meta["annotations"].append({
                      "core:sample_start": sample_start,
                      "maveric:event": "rx_gain_change",
                      "maveric:rx_gain_db": float(gain_db),
                      "maveric:datetime": stamp,
                      "maveric:datetime_source": stamp_source,
                  })
                  self._write_meta_locked()

          @staticmethod
          def _rx_time_seconds(value):
              try:
                  if pmt.is_tuple(value) and pmt.length(value) >= 2:
                      whole = pmt.to_uint64(pmt.tuple_ref(value, 0))
                      fraction = pmt.to_double(pmt.tuple_ref(value, 1))
                      return float(whole) + float(fraction)
              except Exception:
                  pass
              return None

          def _record_rx_time_tags_locked(self, tags, nread):
              base_sample = self._written // 8
              for tag in sorted(tags, key=lambda item: item.offset):
                  seconds = self._rx_time_seconds(tag.value)
                  if seconds is None:
                      continue
                  sample_start = base_sample + max(0, int(tag.offset - nread))
                  self._time_anchor_sample = sample_start
                  self._time_anchor_seconds = seconds
                  if not self._rx_time_seen:
                      self._rx_time_seen = True
                      zero_seconds = seconds - sample_start / self._samp_rate
                      initial = self._meta["captures"][0]
                      initial["core:datetime"] = self._utc_iso(zero_seconds)
                      initial["maveric:datetime_source"] = "usrp_rx_time"
                      self._meta["global"]["maveric:time_reference"] = (
                          "B210 device time synchronized to host UTC")
                  else:
                      capture = {
                          "core:sample_start": sample_start,
                          "core:datetime": self._utc_iso(seconds),
                          "maveric:event": "rx_time_discontinuity",
                          "maveric:datetime_source": "usrp_rx_time",
                      }
                      if self._last_frequency is not None:
                          capture["core:frequency"] = self._last_frequency
                      self._meta["captures"].append(capture)
                  self._write_meta_locked()

          def _close_quietly(self):
              try:
                  if self._file is not None:
                      self._file.close()
              except Exception:
                  pass
              self._file = None

          def work(self, input_items, output_items):
              n_in = len(input_items[0])
              if self._file is None:
                  return n_in
              try:
                  nread = self.nitems_read(0)
                  with self._lock:
                      remaining_samples = max(0, self._max_bytes - self._written) // 8
                      take = min(n_in, remaining_samples)
                      tags = self.get_tags_in_range(
                          0, nread, nread + take, self._rx_time_key) if take else []
                      self._record_rx_time_tags_locked(tags, nread)
                      if take:
                          self._file.write(input_items[0][:take].tobytes())
                          self._written += take * 8
                      if self._written >= self._max_bytes or take < n_in:
                          self._close_quietly()
                          print(f"iq_recorder: size cap reached; saved {self._data_path} "
                                f"({self._written} bytes)", flush=True)
              except Exception:
                  traceback.print_exc()
                  print("iq_recorder: write failed; IQ capture disabled for this run", flush=True)
                  self._close_quietly()
              return n_in

          def stop(self):
              with self._lock:
                  if self._stop_reported or not self._data_path:
                      return True
                  self._stop_reported = True
                  self._close_quietly()
                  try:
                      if self._written == 0:
                          os.remove(self._data_path)
                          os.remove(self._meta_path)
                          print("iq_recorder: empty capture; files removed", flush=True)
                      else:
                          self._write_meta_locked()
                          print(f"iq_recorder: saved {self._data_path} ({self._written} bytes)", flush=True)
                  except Exception:
                      traceback.print_exc()
              return True
    comment: 'IQ autosave: records the decimated RX stream to SigMF while GSS_IQ_RECORD=1. Mirrors _IqRecorder in MAV_DUO.py.'
  states: {}
- name: epy_block_iq_raw
  id: epy_block
  parameters:
    _source_code: |
      import json
      import os
      import threading
      import time
      import traceback
      from datetime import datetime, timezone

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Env-gated raw IQ recorder for an RX stream tap.

          Two instances run in this flowgraph: the pass recorder on the decimated
          200 ksps stream (GSS_IQ_RECORD, `platform.radio.iq_record`, 8 GB cap)
          and the diagnostic raw recorder on the pre-decimation 1 Msps stream
          (GSS_IQ_RAW_RECORD, `platform.radio.iq_raw_record`, nominally 50 GB).
          Files are created exclusively, never appended, so a same-second restart
          cannot join two runs. The first UHD ``rx_time`` tag (the B210 clock is
          synchronized to host UTC before streaming) stamps sample zero with its
          fractional seconds; later tags preserve discontinuity boundaries.
          Doppler commands and live gain changes are written immediately as
          sample-indexed SigMF capture/annotation entries. Every failure path
          prints and disables the block — capture must never take down the radio.

          Offline replay: gr_satellites <MISSION>_DECODER.yml --iq --samp_rate 200e3
          --rawfile <capture>.sigmf-data
          """

          MAX_BYTES = 8_000_000_000  # ~83 min of 200 ksps complex64

          def __init__(self):
              samp_rate = 1_000_000.0
              prefix = "iqraw"
              gate_env = "GSS_IQ_RAW_RECORD"
              max_bytes = 50_000_000_000
              extra_meta = {
                  "maveric:radio_script": "MAV_DUO",
                  "maveric:tap": "pre_fir_1msps",
              }
              cap_env = "GSS_IQ_RAW_MAX_BYTES"
              gr.sync_block.__init__(self, name="iq_recorder",
                                     in_sig=[np.complex64], out_sig=None)
              self.message_port_register_in(pmt.intern("command"))
              self.set_msg_handler(pmt.intern("command"), self._handle_tune_command)
              self._file = None
              self._data_path = ""
              self._meta_path = ""
              self._written = 0
              self._samp_rate = float(samp_rate)
              self._lock = threading.RLock()
              self._rx_time_key = pmt.intern("rx_time")
              self._rx_time_seen = False
              self._time_anchor_sample = None
              self._time_anchor_seconds = None
              self._last_frequency = None
              self._stop_reported = False
              if cap_env is None:
                  cap_env = ("GSS_IQ_RAW_MAX_BYTES" if gate_env == "GSS_IQ_RAW_RECORD"
                             else "GSS_IQ_MAX_BYTES")
              env_cap = os.environ.get(cap_env, "").strip()
              self._max_bytes = int(env_cap) if env_cap else int(
                  self.MAX_BYTES if max_bytes is None else max_bytes)
              self._meta = None
              gate = os.environ.get(gate_env, "").strip().lower()
              if gate in ("", "0", "false", "no", "off") or self._max_bytes < 8:
                  return
              try:
                  script_dir = os.path.dirname(os.path.abspath(__file__))
                  out_dir = os.environ.get("GSS_IQ_DIR") or os.path.join(script_dir, "iq")
                  os.makedirs(out_dir, exist_ok=True)
                  mission = os.environ.get("GSS_MISSION") or "maveric"
                  constructed = time.time()
                  stem = "%s_%s_%s" % (
                      prefix, mission,
                      time.strftime("%Y%m%dT%H%M%SZ", time.gmtime(constructed)))
                  self._reserve_unique_pair(out_dir, stem)
                  raw_center = os.environ.get("GSS_RX_FREQ_HZ", "")
                  capture = {"core:sample_start": 0,
                             "core:datetime": self._utc_iso(constructed),
                             "maveric:datetime_source": "construction_fallback"}
                  if raw_center:
                      self._last_frequency = float(raw_center)
                      capture["core:frequency"] = self._last_frequency
                  meta = {
                      "global": {
                          "core:datatype": "cf32_le",
                          "core:sample_rate": self._samp_rate,
                          "core:version": "1.0.0",
                          "core:recorder": "MAVERIC GSS",
                          "maveric:constructed_utc": self._utc_iso(constructed),
                      },
                      "captures": [capture],
                      "annotations": [],
                  }
                  provenance = {
                      "maveric:mission": mission,
                      "maveric:rx_gain_db": os.environ.get("GSS_RX_GAIN", ""),
                      "maveric:rx_bw_hz": os.environ.get("GSS_RX_BW_HZ", ""),
                      "maveric:rx_lo_offset_hz": os.environ.get("GSS_RX_LO_OFFSET_HZ", ""),
                      "maveric:build_sha": os.environ.get("GSS_BUILD_SHA", ""),
                  }
                  provenance.update(extra_meta or {})
                  for key, value in provenance.items():
                      if value not in ("", None):
                          meta["global"][key] = value
                  self._meta = meta
                  self._write_meta_locked()
                  print(f"iq_recorder: recording {self._data_path} "
                        f"(cap {self._max_bytes / 1e9:.1f} GB)", flush=True)
              except Exception:
                  traceback.print_exc()
                  print("iq_recorder: init failed; IQ capture disabled", flush=True)
                  self._close_quietly()

          @staticmethod
          def _utc_iso(epoch_seconds):
              return (datetime.fromtimestamp(float(epoch_seconds), timezone.utc)
                      .isoformat(timespec="microseconds").replace("+00:00", "Z"))

          def _reserve_unique_pair(self, out_dir, stem):
              for suffix in range(10_000):
                  candidate = stem if suffix == 0 else f"{stem}_{suffix:03d}"
                  data_path = os.path.join(out_dir, candidate + ".sigmf-data")
                  meta_path = os.path.join(out_dir, candidate + ".sigmf-meta")
                  try:
                      data_file = open(data_path, "xb")
                  except FileExistsError:
                      continue
                  if os.path.exists(meta_path):
                      data_file.close()
                      os.remove(data_path)
                      continue
                  self._data_path = data_path
                  self._meta_path = meta_path
                  self._file = data_file
                  return
              raise RuntimeError(f"could not allocate unique SigMF name for {stem}")

          def _write_meta_locked(self):
              if self._meta is None or not self._meta_path:
                  return
              tmp = f"{self._meta_path}.{os.getpid()}.{threading.get_ident()}.tmp"
              with open(tmp, "w") as meta_file:
                  json.dump(self._meta, meta_file, indent=2)
              os.replace(tmp, self._meta_path)

          @staticmethod
          def _pmt_number(message, key):
              if not pmt.is_dict(message):
                  return None
              value = pmt.dict_ref(message, pmt.intern(key), pmt.PMT_NIL)
              if pmt.eq(value, pmt.PMT_NIL):
                  return None
              try:
                  return float(pmt.to_python(value))
              except Exception:
                  return None

          def _event_datetime_locked(self, sample_start):
              if self._time_anchor_sample is not None:
                  elapsed = ((sample_start - self._time_anchor_sample)
                             / self._samp_rate)
                  return self._utc_iso(self._time_anchor_seconds + elapsed), "usrp_rx_time"
              return self._utc_iso(time.time()), "host_wall_clock"

          def _handle_tune_command(self, message):
              if (pmt.is_pair(message) and pmt.is_symbol(pmt.car(message))
                      and pmt.symbol_to_string(pmt.car(message)) == "rx_gain"):
                  try:
                      self.note_gain(float(pmt.to_python(pmt.cdr(message))))
                  except Exception:
                      pass
                  return
              lo_hz = self._pmt_number(message, "lo_freq")
              dsp_hz = self._pmt_number(message, "dsp_freq")
              frequency_hz = self._pmt_number(message, "freq")
              if lo_hz is not None and dsp_hz is not None:
                  frequency_hz = lo_hz - dsp_hz  # UHD RX tuning convention
              if frequency_hz is not None:
                  self.note_tune(frequency_hz, lo_hz=lo_hz, dsp_hz=dsp_hz,
                                 source="doppler_command")

          def note_tune(self, frequency_hz, *, lo_hz=None, dsp_hz=None,
                        source="live_tune"):
              with self._lock:
                  if self._file is None or self._meta is None:
                      return
                  sample_start = self._written // 8
                  stamp, stamp_source = self._event_datetime_locked(sample_start)
                  capture = {
                      "core:sample_start": sample_start,
                      "core:frequency": float(frequency_hz),
                      "core:datetime": stamp,
                      "maveric:event": source,
                      "maveric:datetime_source": stamp_source,
                  }
                  if lo_hz is not None:
                      capture["maveric:lo_freq_hz"] = float(lo_hz)
                  if dsp_hz is not None:
                      capture["maveric:dsp_freq_hz"] = float(dsp_hz)
                  if sample_start == 0:
                      self._meta["captures"][0].update(capture)
                  else:
                      self._meta["captures"].append(capture)
                  self._last_frequency = float(frequency_hz)
                  self._write_meta_locked()

          def note_gain(self, gain_db):
              with self._lock:
                  if self._file is None or self._meta is None:
                      return
                  sample_start = self._written // 8
                  stamp, stamp_source = self._event_datetime_locked(sample_start)
                  self._meta["annotations"].append({
                      "core:sample_start": sample_start,
                      "maveric:event": "rx_gain_change",
                      "maveric:rx_gain_db": float(gain_db),
                      "maveric:datetime": stamp,
                      "maveric:datetime_source": stamp_source,
                  })
                  self._write_meta_locked()

          @staticmethod
          def _rx_time_seconds(value):
              try:
                  if pmt.is_tuple(value) and pmt.length(value) >= 2:
                      whole = pmt.to_uint64(pmt.tuple_ref(value, 0))
                      fraction = pmt.to_double(pmt.tuple_ref(value, 1))
                      return float(whole) + float(fraction)
              except Exception:
                  pass
              return None

          def _record_rx_time_tags_locked(self, tags, nread):
              base_sample = self._written // 8
              for tag in sorted(tags, key=lambda item: item.offset):
                  seconds = self._rx_time_seconds(tag.value)
                  if seconds is None:
                      continue
                  sample_start = base_sample + max(0, int(tag.offset - nread))
                  self._time_anchor_sample = sample_start
                  self._time_anchor_seconds = seconds
                  if not self._rx_time_seen:
                      self._rx_time_seen = True
                      zero_seconds = seconds - sample_start / self._samp_rate
                      initial = self._meta["captures"][0]
                      initial["core:datetime"] = self._utc_iso(zero_seconds)
                      initial["maveric:datetime_source"] = "usrp_rx_time"
                      self._meta["global"]["maveric:time_reference"] = (
                          "B210 device time synchronized to host UTC")
                  else:
                      capture = {
                          "core:sample_start": sample_start,
                          "core:datetime": self._utc_iso(seconds),
                          "maveric:event": "rx_time_discontinuity",
                          "maveric:datetime_source": "usrp_rx_time",
                      }
                      if self._last_frequency is not None:
                          capture["core:frequency"] = self._last_frequency
                      self._meta["captures"].append(capture)
                  self._write_meta_locked()

          def _close_quietly(self):
              try:
                  if self._file is not None:
                      self._file.close()
              except Exception:
                  pass
              self._file = None

          def work(self, input_items, output_items):
              n_in = len(input_items[0])
              if self._file is None:
                  return n_in
              try:
                  nread = self.nitems_read(0)
                  with self._lock:
                      remaining_samples = max(0, self._max_bytes - self._written) // 8
                      take = min(n_in, remaining_samples)
                      tags = self.get_tags_in_range(
                          0, nread, nread + take, self._rx_time_key) if take else []
                      self._record_rx_time_tags_locked(tags, nread)
                      if take:
                          self._file.write(input_items[0][:take].tobytes())
                          self._written += take * 8
                      if self._written >= self._max_bytes or take < n_in:
                          self._close_quietly()
                          print(f"iq_recorder: size cap reached; saved {self._data_path} "
                                f"({self._written} bytes)", flush=True)
              except Exception:
                  traceback.print_exc()
                  print("iq_recorder: write failed; IQ capture disabled for this run", flush=True)
                  self._close_quietly()
              return n_in

          def stop(self):
              with self._lock:
                  if self._stop_reported or not self._data_path:
                      return True
                  self._stop_reported = True
                  self._close_quietly()
                  try:
                      if self._written == 0:
                          os.remove(self._data_path)
                          os.remove(self._meta_path)
                          print("iq_recorder: empty capture; files removed", flush=True)
                      else:
                          self._write_meta_locked()
                          print(f"iq_recorder: saved {self._data_path} ({self._written} bytes)", flush=True)
                  except Exception:
                      traceback.print_exc()
              return True
    comment: 'Diagnostic raw capture: pre-FIR 1 Msps stream to SigMF while GSS_IQ_RAW_RECORD=1 (50 GB cap). Mirrors the second _IqRecorder instance in MAV_DUO.py.'
  states: {}
- name: epy_block_signal_meter
  id: epy_block
  parameters:
    _source_code: |
      """Per-beacon signal meter (mirror of _SignalMeter in MAV_DUO.py).

      Rolling display-tap spectrum; for each decoded frame from gr-satellites it
      measures the burst (peak, floor, -3 dB, C/N0, Eb/N0, max hold; math in
      signal_meter.py) and adds it to the frame metadata as gss_signal before
      the ZMQ publisher, with the tuned frequency over the burst (RX tune
      commands on `command`) and the offset from nominal GSS_RX_FREQ_HZ. The PTT
      gate exists only in MAV_DUO.py, so this mirror receives no transmit windows.
      """

      import json
      import os
      import sys
      import time
      import traceback

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Measure each decoded beacon; tag its PDU with gss_signal."""

          def __init__(self, samp_rate=200_000.0, baud=9600):
              gr.sync_block.__init__(self, name="signal_meter",
                                     in_sig=[np.complex64], out_sig=None)
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_in(pmt.intern("command"))
              self.set_msg_handler(pmt.intern("pdu_in"), self._handle_pdu)
              self.set_msg_handler(pmt.intern("command"), self._handle_tune_command)
              self._baud = float(baud)
              self._meter = None
              self._floor_from = None     # start of the second the next NOISE_FLOOR covers
              try:
                  script_dir = os.path.dirname(os.path.abspath(__file__))
                  if script_dir not in sys.path:
                      sys.path.insert(0, script_dir)
                  import signal_meter
                  raw_nominal = os.environ.get("GSS_RX_FREQ_HZ", "")
                  self._meter = signal_meter.SignalMeter(
                      samp_rate, nominal_hz=float(raw_nominal) if raw_nominal else None)
                  # boot gain; later steps arrive from blocks_var_to_msg_rx_gain
                  self._meter.note_gain(time.time(), float(os.environ.get("GSS_RX_GAIN", 40)))
              except Exception:
                  traceback.print_exc()
                  print("signal_meter: init failed; beacon measurements disabled", flush=True)

          def note_tx(self, key_time, until):
              if self._meter is not None:
                  self._meter.note_tx(key_time, until)

          def note_tune(self, frequency_hz, source="manual"):
              if self._meter is not None:
                  self._meter.note_tune(time.time(), frequency_hz, source)

          def note_gain(self, gain_db):
              if self._meter is not None:
                  self._meter.note_gain(time.time(), gain_db)

          def _handle_tune_command(self, message):
              # Same parsing as the IQ recorder: a UHD RX tune is lo_freq - dsp_freq.
              if (pmt.is_pair(message) and pmt.is_symbol(pmt.car(message))
                      and pmt.symbol_to_string(pmt.car(message)) == "rx_gain"):
                  try:
                      self.note_gain(float(pmt.to_python(pmt.cdr(message))))
                  except Exception:
                      pass
                  return
              try:
                  if not pmt.is_dict(message):
                      return

                  def number(key):
                      value = pmt.dict_ref(message, pmt.intern(key), pmt.PMT_NIL)
                      return None if pmt.eq(value, pmt.PMT_NIL) else float(pmt.to_python(value))

                  lo_hz, dsp_hz, frequency_hz = number("lo_freq"), number("dsp_freq"), number("freq")
                  if lo_hz is not None and dsp_hz is not None:
                      frequency_hz = lo_hz - dsp_hz
                  if frequency_hz is not None:
                      self.note_tune(frequency_hz, source="doppler")
              except Exception:
                  traceback.print_exc()

          def work(self, input_items, output_items):
              n_in = len(input_items[0])
              if self._meter is None:
                  return n_in
              now = time.time()
              try:
                  self._meter.push(input_items[0], now)
              except Exception:
                  traceback.print_exc()
                  print("signal_meter: spectrum capture failed; measurements disabled for this run", flush=True)
                  self._meter = None
                  return n_in
              self._report_floor(now)
              return n_in

          def _report_floor(self, now):
              # One NOISE_FLOOR line per second for the GSS pass noise-floor record,
              # whether or not a beacon is decoded (RadioService parses it).
              if self._floor_from is None:
                  self._floor_from = now
                  return
              if now - self._floor_from < 1.0:
                  return
              start, self._floor_from = self._floor_from, now
              try:
                  report = self._meter.floor_report(start, now, self._baud)
                  if report is not None:
                      print("NOISE_FLOOR " + json.dumps(report, separators=(",", ":")), flush=True)
              except Exception:
                  traceback.print_exc()
                  print("signal_meter: noise-floor report failed; floor reports disabled for this run", flush=True)
                  self._floor_from = float("inf")

          def _handle_pdu(self, msg):
              out = msg
              try:
                  if self._meter is not None and pmt.is_pair(msg):
                      payload_len = pmt.length(pmt.cdr(msg))
                      meta = pmt.car(msg)
                      if not pmt.is_dict(meta):
                          meta = pmt.make_dict()
                      # A burst decoder that decodes after the fact (SCION-X) says
                      # when its burst ended; measure that burst, not "just now".
                      now = time.time()
                      burst_end = pmt.dict_ref(meta, pmt.intern("gss_burst_end"), pmt.PMT_NIL)
                      if pmt.is_real(burst_end):
                          now = pmt.to_double(burst_end) + 0.1
                      result = self._meter.measure(payload_len * 8.0 / self._baud,
                                                   self._baud, now)
                      if result is not None:
                          blob = json.dumps(result, separators=(",", ":")).encode("utf-8")
                          meta = pmt.dict_add(meta, pmt.intern("gss_signal"),
                                              pmt.init_u8vector(len(blob), list(blob)))
                          out = pmt.cons(meta, pmt.cdr(msg))
              except Exception:
                  traceback.print_exc()
                  print("signal_meter: measurement failed; frame forwarded unmeasured", flush=True)
              self.message_port_pub(pmt.intern("pdu_out"), out)
    baud: baud
    comment: 'Per-beacon signal meter: measures each decoded frame on the display tap and tags it with gss_signal before ZMQ. Mirrors _SignalMeter in MAV_DUO.py (TX-window exclusion is Python-only, like the PTT gate).'
    samp_rate: (samp_rate/rx_decim)/disp_decim
  states: {}
- name: epy_block_stream_health
  id: epy_block
  parameters:
    _source_code: |
      """Pre-FIR stream health probe (mirror of _StreamHealthMonitor in
      MAV_DUO.py).

      Reports rms/peak levels (dBFS re the B210's +/-1.0 full scale),
      near-full-scale counts, and overflow events — rx_time stream tags
      after the first, attached by gr-uhd at every stream discontinuity —
      as structured STREAM_HEALTH lines that RadioService parses into
      /api/radio/status. Measured BEFORE any filtering, so gain changes,
      analog overload, and a dead LNA show here first.
      """

      import json
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Report pre-FIR rms/peak/clip levels + overflow count."""

          SAMP_RATE = 1_000_000.0  # keep in sync with samp_rate
          REPORT_EVERY_S = 10.0
          CLIP_LEVEL = 0.99

          def __init__(self):
              gr.sync_block.__init__(self, name="stream_health",
                                     in_sig=[np.complex64], out_sig=None)
              self._rx_time_key = pmt.intern("rx_time")
              self._sumsq = 0.0
              self._peak = 0.0
              self._clip = 0
              self._samples = 0
              self._overflows = 0
              self._stream_started = False
              self._last_report = time.monotonic()

          def _render_report(self, span_s):
              rms = (self._sumsq / self._samples) ** 0.5 if self._samples else 0.0

              def dbfs(value):
                  return round(float(20.0 * np.log10(max(value, 1e-12))), 1)

              return "STREAM_HEALTH " + json.dumps({
                  "rms_dbfs": dbfs(rms),
                  "peak_dbfs": dbfs(self._peak),
                  "clip_count": int(self._clip),
                  "overflows_total": int(self._overflows),
                  "span_s": round(span_s, 1),
              })

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              if n:
                  mag2 = (x.real.astype(np.float64) ** 2
                          + x.imag.astype(np.float64) ** 2)
                  self._sumsq += float(mag2.sum())
                  self._peak = max(self._peak, float(np.sqrt(mag2.max())))
                  self._clip += int(np.count_nonzero(np.maximum(
                      np.abs(x.real), np.abs(x.imag)) >= self.CLIP_LEVEL))
                  self._samples += n
                  nread = self.nitems_read(0)
                  for _tag in self.get_tags_in_range(0, nread, nread + n,
                                                     self._rx_time_key):
                      if self._stream_started:
                          self._overflows += 1
                      else:
                          self._stream_started = True
              now = time.monotonic()
              if now - self._last_report >= self.REPORT_EVERY_S and self._samples:
                  print(self._render_report(now - self._last_report), flush=True)
                  self._sumsq = 0.0
                  self._peak = 0.0
                  self._clip = 0
                  self._samples = 0
                  self._last_report = now
              return n
    comment: 'Pre-FIR stream health: rms/peak/clip dBFS + overflow count (rx_time tag discontinuities) as STREAM_HEALTH lines for /api/radio/status. Mirrors _StreamHealthMonitor in MAV_DUO.py.'
  states: {}
- name: epy_block_tx_health
  id: epy_block
  parameters:
    _source_code: |
      import json
      import threading

      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Turn UHD TX async metadata into structured, live telemetry.

          UHD fast-path characters stay disabled by RadioService because they
          corrupt line-oriented logs. This block consumes the sink's async message
          port instead, reports errors immediately, and emits a 10-second heartbeat
          (including zero totals) so a quiet transmitter is distinguishable from
          dead instrumentation.
          """

          UNDERFLOW_MASK = 0x2 | 0x10
          SEQUENCE_MASK = 0x4 | 0x20
          TIME_ERROR_MASK = 0x8
          EVENT_CODES = {
              "burst_ack": 0x1,
              "underflow": 0x2,
              "seq_error": 0x4,
              "time_error": 0x8,
              "underflow_in_packet": 0x10,
              "seq_error_in_burst": 0x20,
          }

          def __init__(self):
              report_every_s = 10.0
              gr.basic_block.__init__(self, name="tx_async_monitor",
                                      in_sig=[], out_sig=[])
              self._every = float(report_every_s)
              self._underflows = 0
              self._sequence_errors = 0
              self._time_errors = 0
              self._last_event_code = 0
              self._lock = threading.Lock()
              self._stop_event = threading.Event()
              self._thread = None
              self.message_port_register_in(pmt.intern("async"))
              self.set_msg_handler(pmt.intern("async"), self._handle)

          def _report(self):
              with self._lock:
                  payload = {
                      "underflows_total": self._underflows,
                      "seq_errors_total": self._sequence_errors,
                      "time_errors_total": self._time_errors,
                      "last_event_code": self._last_event_code,
                  }
              print("TX_HEALTH " + json.dumps(payload), flush=True)

          def _handle(self, message):
              try:
                  events = self._event_symbols(message)
                  code = 0
                  for event in events:
                      code |= self.EVENT_CODES.get(event, 0)
                  is_error = bool(code & (
                      self.UNDERFLOW_MASK | self.SEQUENCE_MASK | self.TIME_ERROR_MASK))
                  with self._lock:
                      self._last_event_code = code
                      self._underflows += sum(
                          event in ("underflow", "underflow_in_packet")
                          for event in events)
                      self._sequence_errors += sum(
                          event in ("seq_error", "seq_error_in_burst")
                          for event in events)
                      self._time_errors += events.count("time_error")
                  if is_error:
                      self._report()
              except Exception as exc:
                  print(f"tx_async_monitor: malformed UHD metadata: {exc!r}", flush=True)

          @classmethod
          def _event_symbols(cls, message):
              """Extract symbols from gr-uhd's modern async PMT envelope.

              GNU Radio 3.10 publishes ``(uhd_async_msg . {event_code: (...)})``;
              the legacy amsg_source converter expects a removed gr.message type
              and must not be used on this port.
              """
              body = pmt.cdr(message) if pmt.is_pair(message) else message
              if not pmt.is_dict(body):
                  return []
              value = pmt.dict_ref(
                  body, pmt.intern("event_code"), pmt.PMT_NIL)

              def walk(item):
                  if pmt.is_symbol(item):
                      return [pmt.symbol_to_string(item)]
                  if pmt.is_tuple(item):
                      result = []
                      for index in range(pmt.length(item)):
                          result.extend(walk(pmt.tuple_ref(item, index)))
                      return result
                  if pmt.is_vector(item):
                      result = []
                      for index in range(pmt.length(item)):
                          result.extend(walk(pmt.vector_ref(item, index)))
                      return result
                  if pmt.is_pair(item):
                      return walk(pmt.car(item)) + walk(pmt.cdr(item))
                  return []

              return walk(value)

          def _heartbeat(self):
              self._report()
              while not self._stop_event.wait(self._every):
                  self._report()

          def start(self):
              self._stop_event.clear()
              self._thread = threading.Thread(
                  target=self._heartbeat, name="tx-health", daemon=True)
              self._thread.start()
              return True

          def stop(self):
              self._stop_event.set()
              if self._thread is not None:
                  self._thread.join(timeout=1.0)
              return True
    comment: Structured TX underflow/sequence/time-error counters from UHD async metadata, including a 10-second zero-count heartbeat.
  states: {}
- name: epy_block_waterfall
  id: epy_block
  parameters:
    _source_code: |
      """Waterfall autosave logger (mirror of _WaterfallLogger in MAV_DUO.py).

      Appends timestamped 1024-bin dB rows to waterfall_<mission>_<start>_s<span>.dat;
      stop() renders a SatNOGS-style PNG via waterfall_render and deletes the
      .dat on success. Orphaned .dat files from hard crashes render on next
      start; the `_s<hz>` stem token keeps their frequency axis correct even
      when the next run uses a different rx_bw.
      """

      import os
      import struct
      import sys
      import threading
      import time
      import traceback

      import numpy as np
      from gnuradio import gr
      from gnuradio.fft import window


      class blk(gr.sync_block):
          """Log RX FFT rows; render PNG on stop."""

          FFT_SIZE = 1024
          FFTS_PER_ROW = 20

          def __init__(self, samp_rate=200_000.0):
              gr.sync_block.__init__(self, name="waterfall_logger",
                                     in_sig=[np.complex64], out_sig=None)
              self._file = None
              self._dat_path = ""
              self._render_mod = None
              raw_center = os.environ.get("GSS_RX_FREQ_HZ", "")
              self._center_hz = float(raw_center) if raw_center else None
              self._span_hz = float(samp_rate)
              try:
                  script_dir = os.path.dirname(os.path.abspath(__file__))
                  if script_dir not in sys.path:
                      sys.path.insert(0, script_dir)
                  import waterfall_render
                  self._render_mod = waterfall_render
                  out_dir = os.environ.get("GSS_WATERFALL_DIR") or os.path.join(script_dir, "waterfalls")
                  os.makedirs(out_dir, exist_ok=True)
                  orphans = [os.path.join(out_dir, name) for name in sorted(os.listdir(out_dir))
                             if name.startswith("waterfall_") and name.endswith(".dat")]
                  if orphans:
                      threading.Thread(target=self._render_orphans, args=(orphans,),
                                       daemon=True, name="waterfall-orphans").start()
                  mission = os.environ.get("GSS_MISSION") or "maveric"
                  stem = "waterfall_%s_%s_s%d" % (
                      mission, time.strftime("%Y%m%dT%H%M%SZ", time.gmtime()),
                      int(self._span_hz))
                  self._dat_path = os.path.join(out_dir, stem + ".dat")
                  self._file = open(self._dat_path, "ab")
                  self._win = np.asarray(window.blackmanharris(self.FFT_SIZE), dtype=np.float32)
                  self._buf = np.empty(0, dtype=np.complex64)
                  self._acc = np.zeros(self.FFT_SIZE, dtype=np.float64)
                  self._nacc = 0
              except Exception:
                  traceback.print_exc()
                  print("waterfall_logger: init failed; waterfall capture disabled", flush=True)
                  self._close_quietly()

          def _close_quietly(self):
              try:
                  if self._file is not None:
                      self._file.close()
              except Exception:
                  pass
              self._file = None

          def _render_orphans(self, paths):
              for path in paths:
                  try:
                      png = self._render_mod.render(path, delete_dat=True,
                                                    center_freq_hz=self._center_hz)
                      if png is None:
                          print(f"waterfall_logger: removed empty leftover {path}", flush=True)
                      else:
                          print(f"waterfall_logger: rendered leftover {png}", flush=True)
                  except Exception:
                      traceback.print_exc()
                      print(f"waterfall_logger: leftover render failed; kept {path}", flush=True)

          def work(self, input_items, output_items):
              n_in = len(input_items[0])
              if self._file is None:
                  return n_in
              try:
                  self._buf = np.concatenate((self._buf, input_items[0]))
                  while self._buf.size >= self.FFT_SIZE:
                      chunk = self._buf[:self.FFT_SIZE]
                      self._buf = self._buf[self.FFT_SIZE:]
                      spec = np.fft.fft(chunk * self._win)
                      self._acc += spec.real ** 2 + spec.imag ** 2
                      self._nacc += 1
                      if self._nacc >= self.FFTS_PER_ROW:
                          mean_power = self._acc / (self._nacc * self.FFT_SIZE ** 2)
                          row = 10.0 * np.log10(mean_power + 1e-20)
                          row = np.fft.fftshift(row).astype("<f4")
                          self._file.write(struct.pack("<d", time.time()) + row.tobytes())
                          self._file.flush()
                          self._acc[:] = 0.0
                          self._nacc = 0
              except Exception:
                  traceback.print_exc()
                  print("waterfall_logger: capture failed; waterfall disabled for this run", flush=True)
                  self._close_quietly()
              return n_in

          def stop(self):
              if self._file is None:
                  return True
              self._close_quietly()
              try:
                  png = self._render_mod.render(self._dat_path, delete_dat=True,
                                                center_freq_hz=self._center_hz)
                  if png is None:
                      print("waterfall_logger: empty capture; nothing to render", flush=True)
                  else:
                      print(f"waterfall_logger: saved {png}", flush=True)
              except Exception:
                  traceback.print_exc()
                  print(f"waterfall_logger: render failed; kept {self._dat_path}", flush=True)
              return True
    comment: 'Waterfall autosave: logs FFT rows during the run, renders a PNG on stop, sweeps crash leftovers on start. Rides the display tap so saved PNGs span the configured channel. Mirrors _WaterfallLogger in MAV_DUO.py.'
    samp_rate: (samp_rate/rx_decim)/disp_decim
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    comment: Channel filter + decimate 1 Msps to 200 ksps; one-sided cutoff rx_bw with 15k transition stays alias-free across the slider range (output Nyquist 100 kHz)
    decim: rx_decim
    taps: firdes.low_pass(2.0, samp_rate, rx_bw, 15e3)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    comment: Required by variable_function_probe template
    imports: import functools
  states: {}
- name: layout_stretch_snippet
  id: snippet
  parameters:
    section: main_after_init
    code: |-
      self.top_grid_layout.setRowStretch(0, 0)
      self.top_grid_layout.setRowStretch(1, 0)
      self.top_grid_layout.setRowStretch(2, 1)
      self.top_grid_layout.setRowStretch(3, 1)
      self.top_grid_layout.setRowStretch(4, 0)
  states: {}
- name: usrp_info_snippet
  id: snippet
  parameters:
    section: main_after_init
    priority: '1'
    code: |-
      # Report which USRP this run uses as one structured `USRP_INFO {json}`
      # line (RadioService tags pass records with the serial). Never fatal.
      # Mirrors _report_usrp_info() in MAV_DUO.py.
      import json as _json
      try:
          _info = self.uhd_usrp_source_0.get_usrp_info(0)
          print("USRP_INFO " + _json.dumps({
              "serial": str(_info["mboard_serial"]),
              "product": str(_info["mboard_id"]),
              "name": str(_info["mboard_name"]) if "mboard_name" in _info.keys() else "",
          }), flush=True)
      except Exception as exc:
          print(f"usrp_info: serial read failed: {exc}", flush=True)
  states: {}
- name: rx_actual_freq
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source_0
    comment: USRP-reported RX center freq (Hz)
    function_args: '0'
    function_name: get_center_freq
    poll_rate: '2'
    value: '0'
  states: {}
- name: tx_actual_freq
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink_0
    comment: USRP-reported TX center freq (Hz)
    function_args: '0'
    function_name: get_center_freq
    poll_rate: '2'
    value: '0'
  states: {}
- name: rx_actual_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda v: f"{float(v)/1e6:.6f} MHz"'
    gui_hint: 1,0,1,1
    label: USRP RX achieved
    type: real
    value: rx_actual_freq
  states: {}
- name: tx_actual_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda v: f"{float(v)/1e6:.6f} MHz"'
    gui_hint: 1,1,1,1
    label: USRP TX achieved
    type: real
    value: tx_actual_freq
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_ratetx
    fc: tx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,1,1,1
    label: TX Spectrum
    legend: 'False'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: (samp_rate/rx_decim)/disp_decim
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    legend: 'False'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: (samp_rate/rx_decim)/disp_decim
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,2
    type: complex
    update_time: '0.05'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_hexdump_sink_0_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: decoder_yml
    iq: 'True'
    options: decoder_options
    samp_rate: int(samp_rate/rx_decim)
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(tx_freq, tx_lo_offset)
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_ratetx
    sd_spec0: '"A:A"'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(rx_freq, rx_lo_offset)
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: pc_clock
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: f"tcp://127.0.0.1:{zmq_port_rx}"
    comment: Decoded packets to MAV_RX.py
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: f"tcp://127.0.0.1:{zmq_port_tx}"
    comment: Receives ASM+Golay frames from MAV_TX.py
    timeout: '200'
  states: {}
- name: zeromq_sub_msg_source_rxcmd
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://127.0.0.1:52003"'
    comment: Doppler RX center freq commands from GSS
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_txcmd
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://127.0.0.1:52004"'
    comment: Doppler TX center freq commands from GSS
    timeout: '100'
  states: {}

connections:
- [blocks_var_to_msg_rx_gain, msgout, epy_block_iq, command]
- [blocks_var_to_msg_rx_gain, msgout, epy_block_iq_raw, command]
- [blocks_var_to_msg_rx_gain, msgout, epy_block_signal_meter, command]
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_gfsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [fir_filter_xxx_1, '0', epy_block_iq, '0']
- [blocks_keep_one_in_n_0, '0', epy_block_waterfall, '0']
- [blocks_keep_one_in_n_0, '0', epy_block_signal_meter, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_waterfall_sink_x_0, '0']
- [fir_filter_xxx_1, '0', blocks_keep_one_in_n_0, '0']
- [fir_filter_xxx_1, '0', satellites_satellite_decoder_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [satellites_satellite_decoder_0, out, satellites_hexdump_sink_0, in]
- [satellites_satellite_decoder_0, out, epy_block_signal_meter, pdu_in]
- [epy_block_signal_meter, pdu_out, zeromq_pub_msg_sink_0, in]
- [uhd_usrp_source_0, '0', epy_block_iq_raw, '0']
- [uhd_usrp_source_0, '0', epy_block_stream_health, '0']
- [uhd_usrp_source_0, '0', fir_filter_xxx_1, '0']
- [uhd_usrp_sink_0, async_msgs, epy_block_tx_health, async]
- [zeromq_sub_msg_source_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zeromq_sub_msg_source_0, out, satellites_hexdump_sink_0_0, in]
- [zeromq_sub_msg_source_rxcmd, out, uhd_usrp_source_0, command]
- [zeromq_sub_msg_source_rxcmd, out, epy_block_iq, command]
- [zeromq_sub_msg_source_rxcmd, out, epy_block_signal_meter, command]
- [zeromq_sub_msg_source_rxcmd, out, epy_block_iq_raw, command]
- [zeromq_sub_msg_source_txcmd, out, uhd_usrp_sink_0, command]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
