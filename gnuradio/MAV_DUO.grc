options:
  parameters:
    author: Irfan Annuar - USC ISI SERC
    copyright: USC ISI SERC
    description: MAVERIC CubeSat ASM+Golay Uplink (AX100 Mode 5) + Full Duplex RX
    generate_options: qt_gui
    id: MAV_DUO
    output_language: python
    title: MAVERIC DUAL FRAME
  states: {}

blocks:
- name: rx_decim
  id: variable
  parameters:
    comment: RX decimation 1Msps -> 200ksps for satellite_decoder + displays
    value: '5'
  states: {}
- name: rx_lo_offset
  id: variable
  parameters:
    comment: |-
      RX LO parks this far above rx_freq; doppler rides the DSP NCO.
      Single-sourced from tracking.control.rx_lo_offset_hz via the GSS_RX_LO_OFFSET_HZ
      env var RadioService injects; the literal is the standalone-launch fallback.
    value: float(__import__('os').environ.get('GSS_RX_LO_OFFSET_HZ', 250e3))
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      TX LO parks this far below tx_freq; keeps TX LO leak + LO-vs-LO
      beat products out of the RX passband. Single-sourced from tracking.control.tx_lo_offset_hz
      via GSS_TX_LO_OFFSET_HZ; the literal is the standalone-launch fallback.
    value: float(__import__('os').environ.get('GSS_TX_LO_OFFSET_HZ', -400e3))
  states: {}
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    comment: |-
      RX center frequency. Seeded from the GSS_RX_FREQ_HZ env var RadioService
      injects (config rx.frequency / tracking.frequencies.rx_hz); the literal is the
      standalone-launch fallback. Doppler retunes live via 52003.
    value: float(__import__('os').environ.get('GSS_RX_FREQ_HZ', 437.575e6))
  states: {}
- name: tx_freq
  id: variable
  parameters:
    comment: |-
      TX center frequency. Seeded from the GSS_TX_FREQ_HZ env var RadioService
      injects (config tx.frequency / tracking.frequencies.tx_hz); the literal is the
      standalone-launch fallback. Doppler retunes live via 52004.
    value: float(__import__('os').environ.get('GSS_TX_FREQ_HZ', 437.575e6))
  states: {}
- name: modindex
  id: variable
  parameters:
    comment: AX100 Default
    value: 1/1.5
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: SDR RF TX burst gain (applied by the PTT gate during TX; hardware idles at 0 dB)
    gui_hint: 0,1,1,1
    label: TX Gain (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: SDR RF RX gain (B210 max 76 dB)
    gui_hint: 4,0,1,2
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RX sample rate (independent of TX)
    value: '1000000'
  states: {}
- name: samp_ratetx
  id: variable
  parameters:
    comment: Fixed 2.4 Msps = 48MHz/20 with RX at 1Msps (clean B210 divisor at both baud rates)
    value: '2400000'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    comment: Baseband TX amplitude
    gui_hint: 0,0,1,1
    label: TX Amplitude
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.7'
  states: {}
- name: zmq_port_rx
  id: variable
  parameters:
    comment: |-
      ZMQ Port 
      PDU Output
    value: '"52001"'
  states: {}
- name: zmq_port_tx
  id: variable
  parameters:
    comment: |-
      ZMQ Port
      PDU Input
    value: '"52002"'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: TX amplitude control
    const: tx_amp
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: maveric_recordingax25u8.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    comment: 'AX100: GFSK BT=0.5, m=auto, NRZ MSB-first'
    samples_per_symbol: int(samp_ratetx/baud)
    sensitivity: (pi*modindex) / int(samp_ratetx/baud)
  states: {}
- name: epy_block_waterfall
  id: epy_block
  parameters:
    _source_code: |
      """Waterfall autosave logger (mirror of _WaterfallLogger in MAV_DUO.py).

      Appends timestamped 1024-bin dB rows to waterfall_<start>.dat; stop()
      renders a SatNOGS-style PNG via waterfall_render and deletes the .dat
      on success. Orphaned .dat files from hard crashes render on next start.
      """

      import os
      import struct
      import sys
      import threading
      import time
      import traceback

      import numpy as np
      from gnuradio import gr
      from gnuradio.fft import window


      class blk(gr.sync_block):
          """Log RX FFT rows; render PNG on stop."""

          FFT_SIZE = 1024
          FFTS_PER_ROW = 20

          def __init__(self):
              gr.sync_block.__init__(self, name="waterfall_logger",
                                     in_sig=[np.complex64], out_sig=None)
              self._file = None
              self._dat_path = ""
              self._render_mod = None
              raw_center = os.environ.get("GSS_RX_FREQ_HZ", "")
              self._center_hz = float(raw_center) if raw_center else None
              try:
                  script_dir = os.path.dirname(os.path.abspath(__file__))
                  if script_dir not in sys.path:
                      sys.path.insert(0, script_dir)
                  import waterfall_render
                  self._render_mod = waterfall_render
                  out_dir = os.environ.get("GSS_WATERFALL_DIR") or os.path.join(script_dir, "waterfalls")
                  os.makedirs(out_dir, exist_ok=True)
                  orphans = [os.path.join(out_dir, name) for name in sorted(os.listdir(out_dir))
                             if name.startswith("waterfall_") and name.endswith(".dat")]
                  if orphans:
                      threading.Thread(target=self._render_orphans, args=(orphans,),
                                       daemon=True, name="waterfall-orphans").start()
                  mission = os.environ.get("GSS_MISSION") or "maveric"
                  stem = "waterfall_%s_%s" % (mission, time.strftime("%Y%m%dT%H%M%SZ", time.gmtime()))
                  self._dat_path = os.path.join(out_dir, stem + ".dat")
                  self._file = open(self._dat_path, "ab")
                  self._win = np.asarray(window.blackmanharris(self.FFT_SIZE), dtype=np.float32)
                  self._buf = np.empty(0, dtype=np.complex64)
                  self._acc = np.zeros(self.FFT_SIZE, dtype=np.float64)
                  self._nacc = 0
              except Exception:
                  traceback.print_exc()
                  print("waterfall_logger: init failed; waterfall capture disabled", flush=True)
                  self._close_quietly()

          def _close_quietly(self):
              try:
                  if self._file is not None:
                      self._file.close()
              except Exception:
                  pass
              self._file = None

          def _render_orphans(self, paths):
              for path in paths:
                  try:
                      png = self._render_mod.render(path, delete_dat=True,
                                                    center_freq_hz=self._center_hz)
                      if png is None:
                          print(f"waterfall_logger: removed empty leftover {path}", flush=True)
                      else:
                          print(f"waterfall_logger: rendered leftover {png}", flush=True)
                  except Exception:
                      traceback.print_exc()
                      print(f"waterfall_logger: leftover render failed; kept {path}", flush=True)

          def work(self, input_items, output_items):
              n_in = len(input_items[0])
              if self._file is None:
                  return n_in
              try:
                  self._buf = np.concatenate((self._buf, input_items[0]))
                  while self._buf.size >= self.FFT_SIZE:
                      chunk = self._buf[:self.FFT_SIZE]
                      self._buf = self._buf[self.FFT_SIZE:]
                      spec = np.fft.fft(chunk * self._win)
                      self._acc += spec.real ** 2 + spec.imag ** 2
                      self._nacc += 1
                      if self._nacc >= self.FFTS_PER_ROW:
                          mean_power = self._acc / (self._nacc * self.FFT_SIZE ** 2)
                          row = 10.0 * np.log10(mean_power + 1e-20)
                          row = np.fft.fftshift(row).astype("<f4")
                          self._file.write(struct.pack("<d", time.time()) + row.tobytes())
                          self._file.flush()
                          self._acc[:] = 0.0
                          self._nacc = 0
              except Exception:
                  traceback.print_exc()
                  print("waterfall_logger: capture failed; waterfall disabled for this run", flush=True)
                  self._close_quietly()
              return n_in

          def stop(self):
              if self._file is None:
                  return True
              self._close_quietly()
              try:
                  png = self._render_mod.render(self._dat_path, delete_dat=True,
                                                center_freq_hz=self._center_hz)
                  if png is None:
                      print("waterfall_logger: empty capture; nothing to render", flush=True)
                  else:
                      print(f"waterfall_logger: saved {png}", flush=True)
              except Exception:
                  traceback.print_exc()
                  print(f"waterfall_logger: render failed; kept {self._dat_path}", flush=True)
              return True
    comment: 'Waterfall autosave: logs FFT rows during the run, renders a PNG on stop, sweeps crash leftovers on start. Mirrors _WaterfallLogger in MAV_DUO.py.'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    comment: Decimate 1Msps to 200ksps for satellite_decoder
    decim: rx_decim
    taps: '[0.000332675437675789,-0.0003077496658079326,-0.0005765556124970317,-0.00011316717427689582,0.0005280854529701173,0.0005271750269457698,-0.0001697568513918668,-0.0007128709694370627,-0.0003659247304312885,0.0005136664258316159,0.0008155554533004761,5.7438082876615226e-05,-0.0008846476557664573,-0.0007628710591234267,0.0004127955762669444,0.0012023845920339227,0.0004748026258312166,-0.0010086969705298543,-0.0013431194238364697,9.995983418775722e-05,0.0016230839537456632,0.0011655620764940977,-0.0009432621882297099,-0.0020785757806152105,-0.0005570970242843032,0.0019362160237506032,0.0021571165416389704,-0.0005106113385409117,-0.0028525725938379765,-0.0016568709397688508,0.0019336760742589831,0.003387211123481393,0.0004655412049032748,-0.003454529447481036,-0.0032212010119110346,0.0013689876068383455,0.0046819280833005905,0.0021136386785656214,-0.0035935540217906237,-0.00515820411965251,3.445093100358828e-17,0.00575077161192894,0.004466922953724861,-0.002929744776338339,-0.007238117977976799,-0.0023611208889633417,0.006200101692229509,0.007423438131809235,-0.0011174040846526623,-0.009085707366466522,-0.0057998886331915855,0.005560645833611488,0.010719634592533112,0.0021501574665308,-0.010186892002820969,-0.01026318408548832,0.003317480208352208,0.013918614946305752,0.00710933655500412,-0.009897337295114994,-0.015542840585112572,-0.0010805262718349695,0.01640382409095764,0.013931216672062874,-0.007421362679451704,-0.02128412388265133,-0.00828002393245697,0.017346151173114777,0.02280677668750286,-0.0016788907814770937,-0.027019726112484932,-0.019278328865766525,0.015544342808425426,0.03423699364066124,0.009204991161823273,-0.032225217670202255,-0.03633292764425278,0.008750508539378643,0.0500480942428112,0.029977144673466682,-0.036387741565704346,-0.0669822171330452,-0.009797654114663601,0.07862082123756409,0.08094607293605804,-0.03907700628042221,-0.15815693140029907,-0.0901409462094307,0.21769128739833832,0.5918497443199158,0.7601303458213806,0.5918497443199158,0.21769128739833832,-0.0901409462094307,-0.15815693140029907,-0.03907700628042221,0.08094607293605804,0.07862082123756409,-0.009797654114663601,-0.0669822171330452,-0.036387741565704346,0.029977144673466682,0.0500480942428112,0.008750508539378643,-0.03633292764425278,-0.032225217670202255,0.009204991161823273,0.03423699364066124,0.015544342808425426,-0.019278328865766525,-0.027019726112484932,-0.0016788907814770937,0.02280677668750286,0.017346151173114777,-0.00828002393245697,-0.02128412388265133,-0.007421362679451704,0.013931216672062874,0.01640382409095764,-0.0010805262718349695,-0.015542840585112572,-0.009897337295114994,0.00710933655500412,0.013918614946305752,0.003317480208352208,-0.01026318408548832,-0.010186892002820969,0.0021501574665308,0.010719634592533112,0.005560645833611488,-0.0057998886331915855,-0.009085707366466522,-0.0011174040846526623,0.007423438131809235,0.006200101692229509,-0.0023611208889633417,-0.007238117977976799,-0.002929744776338339,0.004466922953724861,0.00575077161192894,3.445093100358828e-17,-0.00515820411965251,-0.0035935540217906237,0.0021136386785656214,0.0046819280833005905,0.0013689876068383455,-0.0032212010119110346,-0.003454529447481036,0.0004655412049032748,0.003387211123481393,0.0019336760742589831,-0.0016568709397688508,-0.0028525725938379765,-0.0005106113385409117,0.0021571165416389704,0.0019362160237506032,-0.0005570970242843032,-0.0020785757806152105,-0.0009432621882297099,0.0011655620764940977,0.0016230839537456632,9.995983418775722e-05,-0.0013431194238364697,-0.0010086969705298543,0.0004748026258312166,0.0012023845920339227,0.0004127955762669444,-0.0007628710591234267,-0.0008846476557664573,5.7438082876615226e-05,0.0008155554533004761,0.0005136664258316159,-0.0003659247304312885,-0.0007128709694370627,-0.0001697568513918668,0.0005271750269457698,0.0005280854529701173,-0.00011316717427689582,-0.0005765556124970317,-0.0003077496658079326,0.000332675437675789]'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    comment: Required by variable_function_probe template
    imports: import functools
  states: {}
- name: layout_stretch_snippet
  id: snippet
  parameters:
    section: main_after_init
    code: |-
      self.top_grid_layout.setRowStretch(0, 0)
      self.top_grid_layout.setRowStretch(1, 0)
      self.top_grid_layout.setRowStretch(2, 1)
      self.top_grid_layout.setRowStretch(3, 1)
      self.top_grid_layout.setRowStretch(4, 0)
  states: {}
- name: rx_actual_freq
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source_0
    comment: USRP-reported RX center freq (Hz)
    function_args: '0'
    function_name: get_center_freq
    poll_rate: '2'
    value: '0'
  states: {}
- name: tx_actual_freq
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink_0
    comment: USRP-reported TX center freq (Hz)
    function_args: '0'
    function_name: get_center_freq
    poll_rate: '2'
    value: '0'
  states: {}
- name: rx_actual_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda v: f"{float(v)/1e6:.6f} MHz"'
    gui_hint: 1,0,1,1
    label: USRP RX achieved
    type: real
    value: rx_actual_freq
  states: {}
- name: tx_actual_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda v: f"{float(v)/1e6:.6f} MHz"'
    gui_hint: 1,1,1,1
    label: USRP TX achieved
    type: real
    value: tx_actual_freq
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_ratetx
    fc: tx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,1,1,1
    label: TX Spectrum
    legend: 'False'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/rx_decim
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    legend: 'False'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/rx_decim
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,2
    type: complex
    update_time: '0.05'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_hexdump_sink_0_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: MAVERIC_DECODER.yml
    iq: 'True'
    samp_rate: int(samp_rate/rx_decim)
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(tx_freq, tx_lo_offset)
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_ratetx
    sd_spec0: '"A:A"'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(rx_freq, rx_lo_offset)
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: f"tcp://127.0.0.1:{zmq_port_rx}"
    comment: Decoded packets to MAV_RX.py
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: f"tcp://127.0.0.1:{zmq_port_tx}"
    comment: Receives ASM+Golay frames from MAV_TX.py
    timeout: '200'
  states: {}
- name: zeromq_sub_msg_source_rxcmd
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://127.0.0.1:52003"'
    comment: Doppler RX center freq commands from GSS
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_txcmd
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://127.0.0.1:52004"'
    comment: Doppler TX center freq commands from GSS
    timeout: '100'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_gfsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [fir_filter_xxx_1, '0', epy_block_waterfall, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_1, '0']
- [fir_filter_xxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [fir_filter_xxx_1, '0', satellites_satellite_decoder_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [satellites_satellite_decoder_0, out, satellites_hexdump_sink_0, in]
- [satellites_satellite_decoder_0, out, zeromq_pub_msg_sink_0, in]
- [uhd_usrp_source_0, '0', fir_filter_xxx_1, '0']
- [zeromq_sub_msg_source_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zeromq_sub_msg_source_0, out, satellites_hexdump_sink_0_0, in]
- [zeromq_sub_msg_source_rxcmd, out, uhd_usrp_source_0, command]
- [zeromq_sub_msg_source_txcmd, out, uhd_usrp_sink_0, command]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
