options:
  parameters:
    author: Irfan Annuar - USC ISI SERC
    copyright: USC ISI SERC
    description: MAVERIC CubeSat ASM+Golay Uplink (AX100 Mode 5) + Full Duplex RX
    generate_options: qt_gui
    id: MAV_DUO
    output_language: python
    title: MAVERIC DUAL FRAME
  states: {}

blocks:
- name: decoder_options
  id: variable
  parameters:
    comment: |-
      gr-satellites options matched to the database: --syncword_threshold
      only parses when an AX100/FX.25 deframer is in the file (a pure AX.25
      database would abort argparse). Mirrors _decoder_options() in MAV_DUO.py.
    value: ('--syncword_threshold 6' * any(l.split('#')[0].strip().startswith('framing:') and ('AX100' in l.split('#')[0] or 'FX.25' in l.split('#')[0]) for l in (open(decoder_yml).read() if __import__('os').path.isfile(decoder_yml) else '').splitlines()))
  states: {}
- name: decoder_yml
  id: variable
  parameters:
    comment: |-
      Per-mission decoder database: GSS_DECODER_YML override, else
      <GSS_MISSION>_DECODER.yml when it exists (e.g. ROADS_DECODER.yml),
      else the MAVERIC database. Mirrors _decoder_yml() in MAV_DUO.py.
    value: (__import__('os').environ.get('GSS_DECODER_YML') or (__import__('os').environ.get('GSS_MISSION', 'maveric').upper() + '_DECODER.yml' if __import__('os').path.isfile(__import__('os').environ.get('GSS_MISSION', 'maveric').upper() + '_DECODER.yml') else 'MAVERIC_DECODER.yml'))
  states: {}
- name: rx_decim
  id: variable
  parameters:
    comment: RX decimation 1Msps -> 200ksps for satellite_decoder + displays
    value: '5'
  states: {}
- name: rx_lo_offset
  id: variable
  parameters:
    comment: |-
      RX LO parks this far above rx_freq; doppler rides the DSP NCO.
      Single-sourced from tracking.control.rx_lo_offset_hz via the GSS_RX_LO_OFFSET_HZ
      env var RadioService injects; the literal is the standalone-launch fallback.
    value: float(__import__('os').environ.get('GSS_RX_LO_OFFSET_HZ', 250e3))
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      TX LO parks this far below tx_freq; keeps TX LO leak + LO-vs-LO
      beat products out of the RX passband. Single-sourced from tracking.control.tx_lo_offset_hz
      via GSS_TX_LO_OFFSET_HZ; the literal is the standalone-launch fallback.
    value: float(__import__('os').environ.get('GSS_TX_LO_OFFSET_HZ', -400e3))
  states: {}
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    comment: |-
      RX center frequency. Seeded from the GSS_RX_FREQ_HZ env var RadioService
      injects (config rx.frequency / tracking.frequencies.rx_hz); the literal is the
      standalone-launch fallback. Doppler retunes live via 52003.
    value: float(__import__('os').environ.get('GSS_RX_FREQ_HZ', 437.575e6))
  states: {}
- name: tx_freq
  id: variable
  parameters:
    comment: |-
      TX center frequency. Seeded from the GSS_TX_FREQ_HZ env var RadioService
      injects (config tx.frequency / tracking.frequencies.tx_hz); the literal is the
      standalone-launch fallback. Doppler retunes live via 52004.
    value: float(__import__('os').environ.get('GSS_TX_FREQ_HZ', 437.575e6))
  states: {}
- name: modindex
  id: variable
  parameters:
    comment: |-
      AX100 auto default: the flight param list shows modindex 0.0 =
      AUTOMATIC, and the manual's auto table picks h = 1/1.5 for 1300-60000
      baud. This exact value was hardware-verified against the flight unit
      in the Mode 5 uplink bench tests. ROADS 2's measured h=0.5 is that
      bird's own config, not the AX100 default.
    value: 1/1.5
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: SDR RF TX burst gain (applied by the PTT gate during TX; hardware idles at 0 dB)
    gui_hint: 0,1,1,1
    label: TX Gain (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      SDR RF RX gain (B210 max 76 dB). Boot value from GSS_RX_GAIN
      (platform.radio.rx_gain, injected by RadioService); the slider
      still overrides live.
    gui_hint: 4,0,1,2
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: float(__import__('os').environ.get('GSS_RX_GAIN', 40))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RX sample rate (independent of TX)
    value: '1000000'
  states: {}
- name: samp_ratetx
  id: variable
  parameters:
    comment: Fixed 2.4 Msps = 48MHz/20 with RX at 1Msps (clean B210 divisor at both baud rates)
    value: '2400000'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    comment: Baseband TX amplitude
    gui_hint: 0,0,1,1
    label: TX Amplitude
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.7'
  states: {}
- name: zmq_port_rx
  id: variable
  parameters:
    comment: |-
      ZMQ Port 
      PDU Output
    value: '"52001"'
  states: {}
- name: zmq_port_tx
  id: variable
  parameters:
    comment: |-
      ZMQ Port
      PDU Input
    value: '"52002"'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: TX amplitude control
    const: tx_amp
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: maveric_recordingax25u8.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    comment: 'AX100: GFSK BT=0.5, m=auto, NRZ MSB-first'
    samples_per_symbol: int(samp_ratetx/baud)
    sensitivity: (pi*modindex) / int(samp_ratetx/baud)
  states: {}
- name: epy_block_iq
  id: epy_block
  parameters:
    _source_code: |
      """Env-gated IQ recorder (mirror of _IqRecorder in MAV_DUO.py).

      Records the decimated RX stream to iq_<mission>_<start>.sigmf-data under
      GSS_IQ_DIR while GSS_IQ_RECORD=1 (both injected by RadioService; gate
      comes from platform.radio.iq_record). SigMF metadata is written up
      front — with capture provenance (mission, RX gain, LO offset, build
      SHA, tap point; the .py twin also records the resolved decoder
      database exactly, here it appears only when GSS_DECODER_YML is set) —
      so a crash still leaves a replayable pair. Size-capped so a forgotten
      toggle cannot fill the disk.
      """

      import json
      import os
      import time
      import traceback

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Record RX IQ to SigMF when GSS_IQ_RECORD=1."""

          SAMP_RATE = 200_000.0  # keep in sync with samp_rate / rx_decim
          MAX_BYTES = 8_000_000_000  # ~83 min of 200 ksps complex64

          def __init__(self):
              gr.sync_block.__init__(self, name="iq_recorder",
                                     in_sig=[np.complex64], out_sig=None)
              self._file = None
              self._data_path = ""
              self._meta_path = ""
              self._written = 0
              self._meta = None
              self._first_sample_pending = False
              gate = os.environ.get("GSS_IQ_RECORD", "").strip().lower()
              if gate in ("", "0", "false", "no", "off"):
                  return
              try:
                  script_dir = os.path.dirname(os.path.abspath(__file__))
                  out_dir = os.environ.get("GSS_IQ_DIR") or os.path.join(script_dir, "iq")
                  os.makedirs(out_dir, exist_ok=True)
                  mission = os.environ.get("GSS_MISSION") or "maveric"
                  start = time.gmtime()
                  stem = "iq_%s_%s" % (mission, time.strftime("%Y%m%dT%H%M%SZ", start))
                  self._data_path = os.path.join(out_dir, stem + ".sigmf-data")
                  self._meta_path = os.path.join(out_dir, stem + ".sigmf-meta")
                  raw_center = os.environ.get("GSS_RX_FREQ_HZ", "")
                  capture = {"core:sample_start": 0,
                             "core:datetime": time.strftime("%Y-%m-%dT%H:%M:%SZ", start)}
                  if raw_center:
                      capture["core:frequency"] = float(raw_center)
                  meta = {
                      "global": {
                          "core:datatype": "cf32_le",
                          "core:sample_rate": float(self.SAMP_RATE),
                          "core:version": "1.0.0",
                          "core:recorder": "MAVERIC GSS",
                      },
                      "captures": [capture],
                      "annotations": [],
                  }
                  provenance = {
                      "maveric:mission": mission,
                      "maveric:rx_gain_db": os.environ.get("GSS_RX_GAIN", ""),
                      "maveric:rx_lo_offset_hz": os.environ.get("GSS_RX_LO_OFFSET_HZ", ""),
                      "maveric:build_sha": os.environ.get("GSS_BUILD_SHA", ""),
                      "maveric:decoder_yml": os.path.basename(os.environ.get("GSS_DECODER_YML", "")),
                      "maveric:radio_script": "MAV_DUO",
                      "maveric:tap": "post_fir_200k",
                  }
                  for key, value in provenance.items():
                      if value not in ("", None):
                          meta["global"][key] = value
                  with open(self._meta_path, "w") as meta_file:
                      json.dump(meta, meta_file, indent=2)
                  self._file = open(self._data_path, "ab")
                  self._meta = meta
                  self._first_sample_pending = True
                  print(f"iq_recorder: recording {self._data_path} "
                        f"(cap {self.MAX_BYTES / 1e9:.0f} GB)", flush=True)
              except Exception:
                  traceback.print_exc()
                  print("iq_recorder: init failed; IQ capture disabled", flush=True)
                  self._close_quietly()

          def _close_quietly(self):
              try:
                  if self._file is not None:
                      self._file.close()
              except Exception:
                  pass
              self._file = None

          def work(self, input_items, output_items):
              n_in = len(input_items[0])
              if self._file is None:
                  return n_in
              if self._first_sample_pending and n_in:
                  self._first_sample_pending = False
                  try:
                      self._meta["global"]["maveric:constructed_utc"] = (
                          self._meta["captures"][0]["core:datetime"])
                      self._meta["captures"][0]["core:datetime"] = time.strftime(
                          "%Y-%m-%dT%H:%M:%SZ", time.gmtime())
                      with open(self._meta_path, "w") as meta_file:
                          json.dump(self._meta, meta_file, indent=2)
                  except Exception:
                      pass  # provisional construction-time meta stays valid
              try:
                  self._file.write(input_items[0].tobytes())
                  self._written += n_in * 8
                  if self._written >= self.MAX_BYTES:
                      self._close_quietly()
                      print(f"iq_recorder: size cap reached; saved {self._data_path} "
                            f"({self._written} bytes)", flush=True)
              except Exception:
                  traceback.print_exc()
                  print("iq_recorder: write failed; IQ capture disabled for this run", flush=True)
                  self._close_quietly()
              return n_in

          def stop(self):
              if self._file is None:
                  return True
              self._close_quietly()
              try:
                  if self._written == 0:
                      os.remove(self._data_path)
                      os.remove(self._meta_path)
                      print("iq_recorder: empty capture; files removed", flush=True)
                  else:
                      print(f"iq_recorder: saved {self._data_path} ({self._written} bytes)", flush=True)
              except Exception:
                  traceback.print_exc()
              return True
    comment: 'IQ autosave: records the decimated RX stream to SigMF while GSS_IQ_RECORD=1. Mirrors _IqRecorder in MAV_DUO.py.'
  states: {}
- name: epy_block_iq_raw
  id: epy_block
  parameters:
    _source_code: |
      """Diagnostic raw 1 Msps IQ recorder (mirror of the second _IqRecorder
      instance in MAV_DUO.py).

      Taps the pre-decimation USRP stream while GSS_IQ_RAW_RECORD=1
      (platform.radio.iq_raw_record) so impulse/QRM structure survives for
      offline blanker work — the post-FIR recording has already filtered
      and spread it. ~8 MB/s with a hard 50 GB cap (~104 min) so a
      forgotten toggle still cannot fill the disk.
      """

      import json
      import os
      import time
      import traceback

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Record raw pre-FIR IQ to SigMF when GSS_IQ_RAW_RECORD=1."""

          SAMP_RATE = 1_000_000.0  # keep in sync with samp_rate
          MAX_BYTES = 50_000_000_000  # ~104 min of 1 Msps complex64

          def __init__(self):
              gr.sync_block.__init__(self, name="iq_raw_recorder",
                                     in_sig=[np.complex64], out_sig=None)
              self._file = None
              self._data_path = ""
              self._meta_path = ""
              self._written = 0
              self._meta = None
              self._first_sample_pending = False
              gate = os.environ.get("GSS_IQ_RAW_RECORD", "").strip().lower()
              if gate in ("", "0", "false", "no", "off"):
                  return
              try:
                  script_dir = os.path.dirname(os.path.abspath(__file__))
                  out_dir = os.environ.get("GSS_IQ_DIR") or os.path.join(script_dir, "iq")
                  os.makedirs(out_dir, exist_ok=True)
                  mission = os.environ.get("GSS_MISSION") or "maveric"
                  start = time.gmtime()
                  stem = "iqraw_%s_%s" % (mission, time.strftime("%Y%m%dT%H%M%SZ", start))
                  self._data_path = os.path.join(out_dir, stem + ".sigmf-data")
                  self._meta_path = os.path.join(out_dir, stem + ".sigmf-meta")
                  raw_center = os.environ.get("GSS_RX_FREQ_HZ", "")
                  capture = {"core:sample_start": 0,
                             "core:datetime": time.strftime("%Y-%m-%dT%H:%M:%SZ", start)}
                  if raw_center:
                      capture["core:frequency"] = float(raw_center)
                  meta = {
                      "global": {
                          "core:datatype": "cf32_le",
                          "core:sample_rate": float(self.SAMP_RATE),
                          "core:version": "1.0.0",
                          "core:recorder": "MAVERIC GSS",
                      },
                      "captures": [capture],
                      "annotations": [],
                  }
                  provenance = {
                      "maveric:mission": mission,
                      "maveric:rx_gain_db": os.environ.get("GSS_RX_GAIN", ""),
                      "maveric:rx_lo_offset_hz": os.environ.get("GSS_RX_LO_OFFSET_HZ", ""),
                      "maveric:build_sha": os.environ.get("GSS_BUILD_SHA", ""),
                      "maveric:radio_script": "MAV_DUO",
                      "maveric:tap": "pre_fir_1msps",
                  }
                  for key, value in provenance.items():
                      if value not in ("", None):
                          meta["global"][key] = value
                  with open(self._meta_path, "w") as meta_file:
                      json.dump(meta, meta_file, indent=2)
                  self._file = open(self._data_path, "ab")
                  self._meta = meta
                  self._first_sample_pending = True
                  print(f"iq_raw_recorder: recording {self._data_path} "
                        f"(cap {self.MAX_BYTES / 1e9:.1f} GB)", flush=True)
              except Exception:
                  traceback.print_exc()
                  print("iq_raw_recorder: init failed; raw capture disabled", flush=True)
                  self._close_quietly()

          def _close_quietly(self):
              try:
                  if self._file is not None:
                      self._file.close()
              except Exception:
                  pass
              self._file = None

          def work(self, input_items, output_items):
              n_in = len(input_items[0])
              if self._file is None:
                  return n_in
              if self._first_sample_pending and n_in:
                  self._first_sample_pending = False
                  try:
                      self._meta["global"]["maveric:constructed_utc"] = (
                          self._meta["captures"][0]["core:datetime"])
                      self._meta["captures"][0]["core:datetime"] = time.strftime(
                          "%Y-%m-%dT%H:%M:%SZ", time.gmtime())
                      with open(self._meta_path, "w") as meta_file:
                          json.dump(self._meta, meta_file, indent=2)
                  except Exception:
                      pass  # provisional construction-time meta stays valid
              try:
                  self._file.write(input_items[0].tobytes())
                  self._written += n_in * 8
                  if self._written >= self.MAX_BYTES:
                      self._close_quietly()
                      print(f"iq_raw_recorder: size cap reached; saved {self._data_path} "
                            f"({self._written} bytes)", flush=True)
              except Exception:
                  traceback.print_exc()
                  print("iq_raw_recorder: write failed; raw capture disabled for this run", flush=True)
                  self._close_quietly()
              return n_in

          def stop(self):
              if self._file is None:
                  return True
              self._close_quietly()
              try:
                  if self._written == 0:
                      os.remove(self._data_path)
                      os.remove(self._meta_path)
                      print("iq_raw_recorder: empty capture; files removed", flush=True)
                  else:
                      print(f"iq_raw_recorder: saved {self._data_path} ({self._written} bytes)", flush=True)
              except Exception:
                  traceback.print_exc()
              return True
    comment: 'Diagnostic raw capture: pre-FIR 1 Msps stream to SigMF while GSS_IQ_RAW_RECORD=1 (50 GB cap). Mirrors the second _IqRecorder instance in MAV_DUO.py.'
  states: {}
- name: epy_block_stream_health
  id: epy_block
  parameters:
    _source_code: |
      """Pre-FIR stream health probe (mirror of _StreamHealthMonitor in
      MAV_DUO.py).

      Reports rms/peak levels (dBFS re the B210's +/-1.0 full scale),
      near-full-scale counts, and overflow events — rx_time stream tags
      after the first, attached by gr-uhd at every stream discontinuity —
      as structured STREAM_HEALTH lines that RadioService parses into
      /api/radio/status. Measured BEFORE any filtering, so gain changes,
      analog overload, and a dead LNA show here first.
      """

      import json
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Report pre-FIR rms/peak/clip levels + overflow count."""

          SAMP_RATE = 1_000_000.0  # keep in sync with samp_rate
          REPORT_EVERY_S = 10.0
          CLIP_LEVEL = 0.99

          def __init__(self):
              gr.sync_block.__init__(self, name="stream_health",
                                     in_sig=[np.complex64], out_sig=None)
              self._rx_time_key = pmt.intern("rx_time")
              self._sumsq = 0.0
              self._peak = 0.0
              self._clip = 0
              self._samples = 0
              self._overflows = 0
              self._stream_started = False
              self._last_report = time.monotonic()

          def _render_report(self, span_s):
              rms = (self._sumsq / self._samples) ** 0.5 if self._samples else 0.0

              def dbfs(value):
                  return round(float(20.0 * np.log10(max(value, 1e-12))), 1)

              return "STREAM_HEALTH " + json.dumps({
                  "rms_dbfs": dbfs(rms),
                  "peak_dbfs": dbfs(self._peak),
                  "clip_count": int(self._clip),
                  "overflows_total": int(self._overflows),
                  "span_s": round(span_s, 1),
              })

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              if n:
                  mag2 = (x.real.astype(np.float64) ** 2
                          + x.imag.astype(np.float64) ** 2)
                  self._sumsq += float(mag2.sum())
                  self._peak = max(self._peak, float(np.sqrt(mag2.max())))
                  self._clip += int(np.count_nonzero(np.maximum(
                      np.abs(x.real), np.abs(x.imag)) >= self.CLIP_LEVEL))
                  self._samples += n
                  nread = self.nitems_read(0)
                  for _tag in self.get_tags_in_range(0, nread, nread + n,
                                                     self._rx_time_key):
                      if self._stream_started:
                          self._overflows += 1
                      else:
                          self._stream_started = True
              now = time.monotonic()
              if now - self._last_report >= self.REPORT_EVERY_S and self._samples:
                  print(self._render_report(now - self._last_report), flush=True)
                  self._sumsq = 0.0
                  self._peak = 0.0
                  self._clip = 0
                  self._samples = 0
                  self._last_report = now
              return n
    comment: 'Pre-FIR stream health: rms/peak/clip dBFS + overflow count (rx_time tag discontinuities) as STREAM_HEALTH lines for /api/radio/status. Mirrors _StreamHealthMonitor in MAV_DUO.py.'
  states: {}
- name: epy_block_waterfall
  id: epy_block
  parameters:
    _source_code: |
      """Waterfall autosave logger (mirror of _WaterfallLogger in MAV_DUO.py).

      Appends timestamped 1024-bin dB rows to waterfall_<start>.dat; stop()
      renders a SatNOGS-style PNG via waterfall_render and deletes the .dat
      on success. Orphaned .dat files from hard crashes render on next start.
      """

      import os
      import struct
      import sys
      import threading
      import time
      import traceback

      import numpy as np
      from gnuradio import gr
      from gnuradio.fft import window


      class blk(gr.sync_block):
          """Log RX FFT rows; render PNG on stop."""

          FFT_SIZE = 1024
          FFTS_PER_ROW = 20

          def __init__(self):
              gr.sync_block.__init__(self, name="waterfall_logger",
                                     in_sig=[np.complex64], out_sig=None)
              self._file = None
              self._dat_path = ""
              self._render_mod = None
              raw_center = os.environ.get("GSS_RX_FREQ_HZ", "")
              self._center_hz = float(raw_center) if raw_center else None
              try:
                  script_dir = os.path.dirname(os.path.abspath(__file__))
                  if script_dir not in sys.path:
                      sys.path.insert(0, script_dir)
                  import waterfall_render
                  self._render_mod = waterfall_render
                  out_dir = os.environ.get("GSS_WATERFALL_DIR") or os.path.join(script_dir, "waterfalls")
                  os.makedirs(out_dir, exist_ok=True)
                  orphans = [os.path.join(out_dir, name) for name in sorted(os.listdir(out_dir))
                             if name.startswith("waterfall_") and name.endswith(".dat")]
                  if orphans:
                      threading.Thread(target=self._render_orphans, args=(orphans,),
                                       daemon=True, name="waterfall-orphans").start()
                  mission = os.environ.get("GSS_MISSION") or "maveric"
                  stem = "waterfall_%s_%s" % (mission, time.strftime("%Y%m%dT%H%M%SZ", time.gmtime()))
                  self._dat_path = os.path.join(out_dir, stem + ".dat")
                  self._file = open(self._dat_path, "ab")
                  self._win = np.asarray(window.blackmanharris(self.FFT_SIZE), dtype=np.float32)
                  self._buf = np.empty(0, dtype=np.complex64)
                  self._acc = np.zeros(self.FFT_SIZE, dtype=np.float64)
                  self._nacc = 0
              except Exception:
                  traceback.print_exc()
                  print("waterfall_logger: init failed; waterfall capture disabled", flush=True)
                  self._close_quietly()

          def _close_quietly(self):
              try:
                  if self._file is not None:
                      self._file.close()
              except Exception:
                  pass
              self._file = None

          def _render_orphans(self, paths):
              for path in paths:
                  try:
                      png = self._render_mod.render(path, delete_dat=True,
                                                    center_freq_hz=self._center_hz)
                      if png is None:
                          print(f"waterfall_logger: removed empty leftover {path}", flush=True)
                      else:
                          print(f"waterfall_logger: rendered leftover {png}", flush=True)
                  except Exception:
                      traceback.print_exc()
                      print(f"waterfall_logger: leftover render failed; kept {path}", flush=True)

          def work(self, input_items, output_items):
              n_in = len(input_items[0])
              if self._file is None:
                  return n_in
              try:
                  self._buf = np.concatenate((self._buf, input_items[0]))
                  while self._buf.size >= self.FFT_SIZE:
                      chunk = self._buf[:self.FFT_SIZE]
                      self._buf = self._buf[self.FFT_SIZE:]
                      spec = np.fft.fft(chunk * self._win)
                      self._acc += spec.real ** 2 + spec.imag ** 2
                      self._nacc += 1
                      if self._nacc >= self.FFTS_PER_ROW:
                          mean_power = self._acc / (self._nacc * self.FFT_SIZE ** 2)
                          row = 10.0 * np.log10(mean_power + 1e-20)
                          row = np.fft.fftshift(row).astype("<f4")
                          self._file.write(struct.pack("<d", time.time()) + row.tobytes())
                          self._file.flush()
                          self._acc[:] = 0.0
                          self._nacc = 0
              except Exception:
                  traceback.print_exc()
                  print("waterfall_logger: capture failed; waterfall disabled for this run", flush=True)
                  self._close_quietly()
              return n_in

          def stop(self):
              if self._file is None:
                  return True
              self._close_quietly()
              try:
                  png = self._render_mod.render(self._dat_path, delete_dat=True,
                                                center_freq_hz=self._center_hz)
                  if png is None:
                      print("waterfall_logger: empty capture; nothing to render", flush=True)
                  else:
                      print(f"waterfall_logger: saved {png}", flush=True)
              except Exception:
                  traceback.print_exc()
                  print(f"waterfall_logger: render failed; kept {self._dat_path}", flush=True)
              return True
    comment: 'Waterfall autosave: logs FFT rows during the run, renders a PNG on stop, sweeps crash leftovers on start. Mirrors _WaterfallLogger in MAV_DUO.py.'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    comment: Decimate 1 Msps to 200 ksps; 80k/15k low-pass anti-aliases the /5 decimation (output Nyquist 100 kHz)
    decim: rx_decim
    taps: firdes.low_pass(2.0, samp_rate, 80e3, 15e3)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    comment: Required by variable_function_probe template
    imports: import functools
  states: {}
- name: layout_stretch_snippet
  id: snippet
  parameters:
    section: main_after_init
    code: |-
      self.top_grid_layout.setRowStretch(0, 0)
      self.top_grid_layout.setRowStretch(1, 0)
      self.top_grid_layout.setRowStretch(2, 1)
      self.top_grid_layout.setRowStretch(3, 1)
      self.top_grid_layout.setRowStretch(4, 0)
  states: {}
- name: rx_actual_freq
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source_0
    comment: USRP-reported RX center freq (Hz)
    function_args: '0'
    function_name: get_center_freq
    poll_rate: '2'
    value: '0'
  states: {}
- name: tx_actual_freq
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink_0
    comment: USRP-reported TX center freq (Hz)
    function_args: '0'
    function_name: get_center_freq
    poll_rate: '2'
    value: '0'
  states: {}
- name: rx_actual_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda v: f"{float(v)/1e6:.6f} MHz"'
    gui_hint: 1,0,1,1
    label: USRP RX achieved
    type: real
    value: rx_actual_freq
  states: {}
- name: tx_actual_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda v: f"{float(v)/1e6:.6f} MHz"'
    gui_hint: 1,1,1,1
    label: USRP TX achieved
    type: real
    value: tx_actual_freq
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_ratetx
    fc: tx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,1,1,1
    label: TX Spectrum
    legend: 'False'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/rx_decim
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    legend: 'False'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/rx_decim
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,2
    type: complex
    update_time: '0.05'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_hexdump_sink_0_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: decoder_yml
    iq: 'True'
    options: decoder_options
    samp_rate: int(samp_rate/rx_decim)
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(tx_freq, tx_lo_offset)
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_ratetx
    sd_spec0: '"A:A"'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(rx_freq, rx_lo_offset)
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: f"tcp://127.0.0.1:{zmq_port_rx}"
    comment: Decoded packets to MAV_RX.py
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: f"tcp://127.0.0.1:{zmq_port_tx}"
    comment: Receives ASM+Golay frames from MAV_TX.py
    timeout: '200'
  states: {}
- name: zeromq_sub_msg_source_rxcmd
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://127.0.0.1:52003"'
    comment: Doppler RX center freq commands from GSS
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_txcmd
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://127.0.0.1:52004"'
    comment: Doppler TX center freq commands from GSS
    timeout: '100'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_gfsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [fir_filter_xxx_1, '0', epy_block_iq, '0']
- [fir_filter_xxx_1, '0', epy_block_waterfall, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_1, '0']
- [fir_filter_xxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [fir_filter_xxx_1, '0', satellites_satellite_decoder_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [satellites_satellite_decoder_0, out, satellites_hexdump_sink_0, in]
- [satellites_satellite_decoder_0, out, zeromq_pub_msg_sink_0, in]
- [uhd_usrp_source_0, '0', epy_block_iq_raw, '0']
- [uhd_usrp_source_0, '0', epy_block_stream_health, '0']
- [uhd_usrp_source_0, '0', fir_filter_xxx_1, '0']
- [zeromq_sub_msg_source_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zeromq_sub_msg_source_0, out, satellites_hexdump_sink_0_0, in]
- [zeromq_sub_msg_source_rxcmd, out, uhd_usrp_source_0, command]
- [zeromq_sub_msg_source_txcmd, out, uhd_usrp_sink_0, command]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
